## Boards/kamoamoa/cpap_pi_control/Kconfig.cpap_pi_control
```kconfig
config BOARD_CPAP_PI_CONTROL
	select SOC_NRF52840_QIAA if BOARD_CPAP_PI_CONTROL_NRF52840
```
